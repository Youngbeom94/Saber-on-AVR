<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar_saber_avrC_32NTT(barrett).ewp</path>
    </project>
    <batchBuild />
</workspace>
