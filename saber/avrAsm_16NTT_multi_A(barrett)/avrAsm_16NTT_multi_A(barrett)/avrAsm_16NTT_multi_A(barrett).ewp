# IAR project avrAsm_16NTT_multi_A(barrett).ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: DLib_Config_Normal.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 6 -v6, Max 16 Mbyte data, 8 Mbyte code
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$/src/template/lnk6h.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: api.h cbd.c cbd.h fips202.c fips202.h invntt3329_barrett_asm.s invntt7681_barrett_asm.s keccakf1600.h kem.c main.c ntt3329_barrett_asm.s ntt7681_barrett_asm.s pack_unpack.c pack_unpack.h poly.c poly.h randombytes.c randombytes.h SABER_indcpa.c SABER_indcpa.h SABER_params.h verify.c verify.h
